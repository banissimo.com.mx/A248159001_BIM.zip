Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Bath-Spas_Roca_GEORGIA-1850x1000-Freestanding-acrylic-b.ifc
Time: 2019-10-10T12:50:18
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: GEORGIA 1850x1000 Freestanding acrylic bath
ePset_BIMobjectScript - Color and finish: White; Instalation Type: With front type; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): GEORGIA 1850x1000 Freestanding acrylic bath; SKU (BO_prodsku): 248159xx1; ManufacturName (BO_Manufac): Roca; BrandUrl (BO_brandurl): http://www.roca.com; ProductFamily (BO_prodfam): Georgia; ProductGroup (BO_prodgroup): Baths; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; PublishDate (BO_publisdat): 10/21/2015; EditionNumber (BO_edinum): 1; Width (BO_width): 1000; Height (BO_height): 420; Depth (BO_depth): 1850; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/roca/product/248159xx1; ProductDataUrl (BO_prodaturl): bimobject.com/roca/product/248159xx1; ProductUrl (BO_producturl): http://www.roca.com/catalogue/products/baths/shaped-baths/without-whirlpool/acrylic-baths/oval-acrylic-bath-waste-kit-248159..1; InstallationInstructions (BO_montins): http://www.roca.com/RocaResourceServlet/resources/getMainResource?idObject={99E290D7-5F46-4AF2-8E45-9AFB5C1A5808}; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=68jtjk-3_i4; MaterialMain (BO_mainmat): Acrylic; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Bath & Spas; BimObjectCategoryCode (BO_bocat_code): sanitary-bath-spas; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L7211; Uniclass14Description (BO_uniclass_1_4_desc): Baths; Uniclass20Code (BO_uniclass_2_0_code): PR-35-06-08; Uniclass20Description (BO_uniclass_2_0_desc): Baths; NBSReference (BO_nbs_ref): 35-06-08; NBSReferenceDescription (BO_nbs_desc): Baths; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
